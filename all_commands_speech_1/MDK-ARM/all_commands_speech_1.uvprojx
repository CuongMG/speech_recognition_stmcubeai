# Keil uVision project all_commands_speech_1.uvprojx, settings and files
target all_commands_speech_1 (6130001::V6.13.1::.\ARMCLANG)
  device: STM32F429IETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: all_commands_speech_1 +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F429xx
  c include: ../X-CUBE-AI/App;../X-CUBE-AI;../Core/Inc;../Middlewares/ST/AI/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\..\..\library_audio\STM32_AI_AudioPreprocessing_Library\STM32_AI_AudioPreprocessing_Library\Inc;..\..\..\library_audio\i2c_lcd\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: all_commands_speech_1.sct
  group Application/MDK-ARM
    ./: startup_stm32f429xx.s
  group Application/User/X-CUBE-AI/App
    ../X-CUBE-AI/App/: speech_model.c speech_model_data.c speech_model_data_params.c app_x-cube-ai.c
  group Application/User/Core
    ../Core/Src/: main.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Doc
    ../X-CUBE-AI/App/: speech_model_generate_report.txt
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_crc.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Lib
    ../Middlewares/ST/AI/Lib/: NetworkRuntime810_CM4_Keil.lib
  group library_audio
    ../../../library_audio/STM32_AI_AudioPreprocessing_Library/STM32_AI_AudioPreprocessing_Library/Src/: common_tables.c dct.c feature_extraction.c mel_filterbank.c window.c
  group i2c_lcd
    ../../../library_audio/i2c_lcd/src/: i2c-lcd.c
software components: CMSIS:CORE 5.3.0, CMSIS:DSP 1.7.0
